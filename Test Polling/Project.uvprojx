# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx-Nucleo-Polling (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F401RE_Nucleo
  AfterMake: fromelf --bin -o STM32F4xx-Nucleo-Polling\STM32F401RE_Nucleo.bin STM32F4xx-Nucleo-Polling\STM32F401RE_Nucleo.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_LOGGER,USE_STM32F4XX_NUCLEO,USE_FULL_ASSERT
  c misc: --C99
  c include: ./Inc;../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/STM32F4xx_HAL_Driver/Inc;../../../../STM32Cube/Repository/STM32Cube_FW_F4_V1.23.0/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/BSP/Components/ST25R3911;../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/BSP/STM32F4xx_Nucleo;../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Middlewares/ST/rfal/Inc;../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Middlewares/ST/rfal/Src../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/CMSIS/Device/ST/STM32F4xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ./Src/: main.c logger.c demo.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c spi.c
  group Drivers/CMSIS
    ../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/Components/ST25R3911
    ../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/BSP/Components/ST25R3911/: st25r3911.c st25r3911_com.c st25r3911_interrupt.c timer.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c
  group Middlewares/ST/RFAL
    ../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Middlewares/ST/rfal/Src/: rfal_isoDep.c rfal_nfca.c rfal_nfcb.c rfal_iso15693_2.c rfal_nfcDep.c rfal_st25tb.c rfal_rfst25r3911.c rfal_nfcf.c rfal_t1t.c rfal_crc.c rfal_analogConfig.c rfal_nfcv.c
software components: CMSIS:CORE 5.1.2
