# IAR project Polling.ewp, settings and files
configuration STM32F4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_LOGGER; USE_STM32F4XX_NUCLEO; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../../Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/BSP/Components/ST25R3911; ../../../../../../Drivers/BSP/STM32F4xx_Nucleo; ../../../../../../Middlewares/ST/rfal/Inc; ../../../../../../Middlewares/ST/rfal/Src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F401RE-Nucleo.bin
  ILINK.IlinkOutputFile: Polling.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User
    ../../Src/: demo.c logger.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c
  group Drivers/BSP/Components/ST25R3911
    ../../../../../../Drivers/BSP/Components/ST25R3911/: st25r3911.c st25r3911_com.c st25r3911_interrupt.c timer.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/ST/RFAL
    ../../../../../../Middlewares/ST/rfal/Src/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_rfst25r3911.c rfal_st25tb.c rfal_t1t.c
