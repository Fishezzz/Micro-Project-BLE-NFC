# Keil uVision project Labopdracht_3_4_BLE.uvprojx, settings and files
target Labopdracht 3 - BLE (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Labopdracht_3_4_BLE
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c include: ..\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Include;..\Middleware\ST\BlueNRG-MS\includes;..\Middleware\ST\BlueNRG-MS\hci\hci_tl_patterns\Basic;..\Middleware\ST\BlueNRG-MS\utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/User
    ../Src/: app_x-cube-ble1.c hci_tl_interface.c main.c nucleo_f401re_bus.c sample_service.c stm32f4_nucleo_f401re.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../Middleware/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Basic
    ../Middleware/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../Middleware/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../Middleware/ST/BlueNRG-MS/utils/: ble_list.c
software components: CMSIS:CORE 5.1.2, Device:STM32Cube Framework:STM32CubeMX 1.0.0
