# Keil uVision project Labopdracht3.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Labopdracht3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ./: startup_stm32f401xe.s
  group Application/User
    ./: main.c demo.c logger.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c hci_tl_interface.c app_x-cube-ble1.c sample_service.c nucleo_f401re_bus.c stm32f4_nucleo_f401re.c
  group Drivers/CMSIS
    ../../../../STM32Cube/Repository/STM32Cube_FW_F4_V1.23.0/Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../STM32Cube/Repository/STM32Cube_FW_F4_V1.23.0/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c
    ./: stm32f4xx_hal_exti.c
  group Drivers/Components/ST25R3911
    ../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Drivers/BSP/Components/ST25R3911/: st25r3911.c st25r3911_com.c st25r3911_interrupt.c timer.c
  group Middlewares/BlueNRG-MS/Wireless/Controller
    ../../../../STM32Cube/Repository/STM32CubeExpansion_BluetoothLowEnergy/Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/HCI_TL/Basic
    ../../../../STM32Cube/Repository/STM32CubeExpansion_BluetoothLowEnergy/Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../STM32Cube/Repository/STM32CubeExpansion_BluetoothLowEnergy/Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/BlueNRG-MS/Wireless/Utils
    ../../../../STM32Cube/Repository/STM32CubeExpansion_BluetoothLowEnergy/Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/ST/RFAL
    ../../../../STM32Cube/Repository/STM32CubeExpansion_NFC5_V1.3.0/Middlewares/ST/rfal/Src/: rfal_isoDep.c rfal_nfca.c rfal_nfcb.c rfal_iso15693_2.c rfal_nfcDep.c rfal_st25tb.c rfal_rfst25r3911.c rfal_nfcf.c rfal_t1t.c rfal_crc.c rfal_analogConfig.c rfal_nfcv.c
  group Dikke/Hash/Kanker/Keil/Spel
    ./Inc/: spi.h app_x-cube-ble1.h ble_list_utils.h bluenrg_conf.h demo.h hci_tl_interface.h logger.h main.h nucleo_f401re_bus.h nucleo_f401re_conf.h nucleo_f401re_errno.h platform.h role_type.h RTE_Components.h sample_service.h stm32f4_nucleo_f401re.h stm32f4xx_hal_conf.h stm32f4xx_it.h stm32l0xx_hal_conf.h stm32l0xx_it.h stm32l4xx_hal_conf.h stm32l4xx_it.h usart.h rfal_analogConfigTbl.h rfal_iso15693_2.h rfal_isoDep.h rfal_nfca.h rfal_nfcb.h rfal_nfcDep.h rfal_nfcf.h rfal_nfcv.h rfal_rf.h rfal_st25tb.h rfal_t1t.h
software components: CMSIS:CORE 5.1.2
